<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>mac_virtual_channel_encoder</key>
<param><key>id</key><value>mac_virtual_channel_encoder_0</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>arq</key><value>1</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>minsize</key><value>5</value></param>
<param><key>maxsize</key><value>5</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>7500</value></param>
</block>
<block>
<key>simple_mac</key>
<param><key>id</key><value>simple_mac_0</value></param>
<param><key>addr</key><value>0</value></param>
<param><key>maximum_attempts</key><value>10</value></param>
<param><key>timeout</key><value>0.1</value></param>
</block>
<block>
<key>simple_mac</key>
<param><key>id</key><value>simple_mac_0_0</value></param>
<param><key>addr</key><value>1</value></param>
<param><key>maximum_attempts</key><value>10</value></param>
<param><key>timeout</key><value>0.1</value></param>
</block>
<connection><source_block_id>simple_mac_0_0</source_block_id><sink_block_id>simple_mac_0</sink_block_id><source_key>to_radio</source_key><sink_key>from_radio</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>mac_virtual_channel_encoder_0</source_block_id><sink_block_id>simple_mac_0_0</sink_block_id><source_key>out</source_key><sink_key>from_app</sink_key></connection>
<connection><source_block_id>simple_mac_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>to_app</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>mac_virtual_channel_encoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>simple_mac_0_0</sink_block_id><source_key>strobe</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>simple_mac_0</source_block_id><sink_block_id>simple_mac_0_0</sink_block_id><source_key>to_radio</source_key><sink_key>from_radio</sink_key></connection>
</flow_graph>
